<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>UVC</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>cmsis</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\cmsis\device\system_8195a.c</name>
    </file>
  </group>
  <group>
    <name>console</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\common\api\at_cmd\atcmd_google.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\common\api\at_cmd\atcmd_sys.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\common\api\at_cmd\atcmd_wifi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\common\api\at_cmd\log_service.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\driver\low_level_io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\driver\rtl_consol.c</name>
    </file>
  </group>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\common\IAR\lib_mdns.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\common\IAR\lib_platform.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\common\IAR\lib_rtlstd.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\common\IAR\lib_usb.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\common\IAR\lib_uvc.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\common\IAR\lib_wlan.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\common\IAR\lib_wps.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\misc\bsp\lib\va0\rom.a</name>
    </file>
  </group>
  <group>
    <name>My-Driver</name>
    <group>
      <name>BL5372</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\MyDriver\BL5372\i2c-bl5372.c</name>
      </file>
    </group>
    <group>
      <name>EEPROM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\MyDriver\EEPROM\EEPROM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\MyDriver\EEPROM\EEPROM_I2C.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\MyDriver\SHT20\IIC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\MyDriver\kalman_filter\Kalman_Filter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\MyDriver\myIIC\myIIC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\MyDriver\SHT20\SHT20.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\MyDriver\Water\Water.c</name>
    </file>
  </group>
  <group>
    <name>network</name>
    <group>
      <name>api</name>
      <group>
        <name>wifi</name>
        <group>
          <name>rtw_wpa_supplicant</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\rtw_wpa_supplicant\wpa_supplicant\wifi_wps_config.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\wifi_conf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\wifi_ind.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\wifi_promisc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\wifi_simple_config.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\drivers\wlan\realtek\src\wifi_skbuf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\wifi_util.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\api\lwip_netconf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\api\wifi_interactive_mode.c</name>
      </file>
    </group>
    <group>
      <name>app</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\api\network\src\ping_test.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\api\network\src\rtl8195a_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\utilities\ssl_client.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\utilities\tcptest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\application\uart_adapter\uart_adapter.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\utilities\update.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\api\network\src\wlan_network.c</name>
      </file>
    </group>
    <group>
      <name>lwip</name>
      <group>
        <name>api</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\api_lib.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\api_msg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\err.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\netbuf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\netdb.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\netifapi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\sockets.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\tcpip.c</name>
        </file>
      </group>
      <group>
        <name>core</name>
        <group>
          <name>ipv4</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\autoip.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\icmp.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\igmp.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\inet.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\inet_chksum.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\ip.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\ip_addr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\ip_frag.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\def.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\dhcp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\dns.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\lwip_timers.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\mem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\memp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\netif.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\pbuf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\raw.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\stats.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\sys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\tcp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\tcp_in.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\tcp_out.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\udp.c</name>
        </file>
      </group>
      <group>
        <name>netif</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\netif\etharp.c</name>
        </file>
      </group>
      <group>
        <name>port</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos\ethernetif.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\drivers\wlan\realtek\src\osdep\lwip_intf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos\sys_arch.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\dhcp\dhcps.c</name>
      </file>
    </group>
    <group>
      <name>mdns</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\mdns\mDNSPlatform.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>os</name>
    <group>
      <name>freertos</name>
      <group>
        <name>portable</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\MemMang\heap_5.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM3\port.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM3\portasm.s</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\freertos\cmsis_os.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\croutine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\event_groups.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\tasks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\timers.c</name>
      </file>
    </group>
    <group>
      <name>osdep</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_service.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\os_dep\mailbox.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\os_dep\osdep_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\os_dep\osdep_service.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\os_dep\tcm_heap.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>peripheral</name>
    <group>
      <name>api</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\analogin_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\dma_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\efuse1_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\efuse2_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\efuse3_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\flash_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\gpio_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\gpio_irq_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\i2c_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\i2s_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\nfc_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\pinmap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\pinmap_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\port_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\pwmout_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\rtc_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\serial_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\sleep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\spi_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\sys_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\timer_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\us_ticker.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\common\us_ticker_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\common\wait_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8195a\wdt_api.c</name>
      </file>
    </group>
    <group>
      <name>hal</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_32k.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_gdma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_i2s.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_mii.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_nfc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_pcm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_pwm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_sdr_controller.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_soc_ps_monitor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_ssi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\src\hal_uart.c</name>
      </file>
    </group>
    <group>
      <name>osdep</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_pmu.c</name>
      </file>
    </group>
    <group>
      <name>rtl8195a</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_gdma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_i2s.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_nfc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_pwm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_ssi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a\src\rtl8195a_uart.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>SDRAM</name>
    <group>
      <name>polarssl</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\aes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\aesni.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\arc4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\asn1parse.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\asn1write.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\base64.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\bignum.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\blowfish.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\camellia.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ccm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\certs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\cipher.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\cipher_wrap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ctr_drbg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\des.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\dhm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ecdh.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ecdsa.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ecp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ecp_curves.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\entropy.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\entropy_poll.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\error.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\gcm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\havege.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\hmac_drbg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\md.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\md2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\md4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\md5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\md_wrap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\memory_buffer_alloc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\net.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\oid.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\padlock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pbkdf2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pk_wrap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pkcs11.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pkcs12.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pkcs5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pkparse.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pkwrite.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ripemd160.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\rsa.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\sha256.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\sha512.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ssl_cache.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ssl_ciphersuites.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ssl_cli.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ssl_srv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ssl_tls.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\threading.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\timing.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\version.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\version_features.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509_create.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509_crl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509_crt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509_csr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509write_crt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509write_csr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\xtea.c</name>
      </file>
    </group>
    <group>
      <name>ssl_ram_map</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\ssl_ram_map\rom\rom_ssl_ram_map.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\ssl_ram_map\ssl_ram_map.c</name>
      </file>
    </group>
    <group>
      <name>wigadget</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\application\wigadget\cloud_link.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\application\wigadget\shtc1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\application\wigadget\wigadget.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\common\api\platform\stdlib_patch.c</name>
    </file>
    <configuration>
      <name>Debug</name>
    </configuration>
    <configuration>
      <name>UVC</name>
    </configuration>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\..\src\main.c</name>
    </file>
  </group>
  <group>
    <name>utilities</name>
    <group>
      <name>example</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\example\example_entry.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\example\googlenest\example_google.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\example\mcast\example_mcast.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\example\mdns\example_mdns.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\example\socket_select\example_socket_select.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\example\ssl_download\example_ssl_download.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\example\uvc\example_uvc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\example\wlan_fast_connect\example_wlan_fast_connect.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\component\common\example\xml\example_xml.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\common\utilities\cJSON.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\common\utilities\uart_socket.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\common\utilities\webserver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\component\common\utilities\xml.c</name>
    </file>
  </group>
</project>


